FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://menabrea.cfg"
