FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://menabrea.cfg"
SRC_URI += "file://0001-net-bcmgenet-fix-fcs-generation-for-fragmented-skbs.patch"
